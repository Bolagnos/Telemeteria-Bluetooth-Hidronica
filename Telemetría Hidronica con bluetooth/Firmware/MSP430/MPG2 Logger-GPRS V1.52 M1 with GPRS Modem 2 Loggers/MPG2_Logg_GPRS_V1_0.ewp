# IAR project MPG2_Logg_GPRS_V1_0.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430df.h
  General.GHeapSize: 8000
  General.GStackSize: 500
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: CADC12.cpp CAlarms.cpp CAlarms.h CBluetooth.cpp CButtonProg.cpp CClockModule.cpp CController.cpp CController.h CDevice.cpp CDevice.h CDMA.cpp CDoor.cpp CEEPROM.cpp CFATDriver.cpp CGPRS.cpp CInputVoltmeter.cpp CLedRGB.cpp CLogger.cpp CMedidor.cpp CMedidor.h CModule.h CMPG2.cpp CPortDetectBT.cpp CPortDoorSw.cpp CPortRGBLED.cpp CRTC_3029_I2C.cpp CSDMemoryCard.cpp CTimerA.cpp CTimerB.cpp CUART.cpp CUart0.cpp CUart1.cpp CWdTimer.cpp lowinit.c start.cpp
