<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MPG2_Logg_GPRS_V1_0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


